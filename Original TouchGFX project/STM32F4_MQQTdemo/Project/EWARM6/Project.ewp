# IAR project Project.ewp, settings and files
configuration STM32F429I-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ST; STM32F429xx; USE_BPP=16; CORE_CM4F; USE_OS_SYSTICK
  ICCARM.CCIncludePath2: ../TouchGFX/gui/include; ..\TouchGFX\target\include; ..\TouchGFX\platform\os; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/texts/include; ../TouchGFX/generated/gui_generated/include; ../../Middlewares/ST/TouchGFX/touchgfx/framework/include; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Drivers\BSP\STM32F429I-Discovery; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32f4xx\Include; ..\TouchGFX\target; ..\Core\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: ST; STM32F429xx; USE_BPP=16; CORE_CM4F; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\TouchGFX\gui\include; ..\TouchGFX\target\include; ..\TouchGFX\platform\os; ..\TouchGFX\generated\fonts\include; ..\TouchGFX\generated\images\include; ..\TouchGFX\generated\texts\include; ..\..\Middlewares\ST\TouchGFX\touchgfx\framework\include; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Drivers\BSP\STM32F429I-Discovery; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32f4xx\Include; ..\TouchGFX\target; ..\Core\Inc
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkExtraOptions: --redirect _ZN8touchgfx12TextProvider10initializeEPKt9__va_list=_ZN8touchgfx12TextProvider10initializeEPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringRTLERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringRTLERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZN8touchgfx7Unicode9vsnprintfEPttPKc9__va_list=_ZN8touchgfx7Unicode9vsnprintfEPttPKc8_VA_LIST; --redirect _ZN8touchgfx7Unicode9vsnprintfEPttPKt9__va_list=_ZN8touchgfx7Unicode9vsnprintfEPttPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthLTREhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthLTREhPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthRTLEhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthRTLEhPKt8_VA_LIST
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c
  group Application/User/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp Font_verdana_40_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_40_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../TouchGFX/generated/gui_generated/src/containers/: MqttMessagesBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/lightscreen_screen
    ../TouchGFX/generated/gui_generated/src/lightscreen_screen/: LightScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/mainscreen_screen
    ../TouchGFX/generated/gui_generated/src/mainscreen_screen/: MainScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/rgbscreen_screen
    ../TouchGFX/generated/gui_generated/src/rgbscreen_screen/: RGBScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/tempscreen_screen
    ../TouchGFX/generated/gui_generated/src/tempscreen_screen/: TempScreenViewBase.cpp
  group Application/User/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: BitmapDatabase.cpp
  group Application/User/TouchGFX/generated/images/__designer
    ../TouchGFX/generated/images/src/__designer/: Blue_Buttons_Round_Edge_icon_button.cpp Blue_Buttons_Round_Edge_icon_button_pressed.cpp Blue_ProgressIndicators_bg_medium_progress_indicator_bg_square_0_degrees.cpp Blue_Slider_Horizontal_Small_Indicators_slider_horizontal_small_round_knob.cpp Blue_Slider_Horizontal_Small_slider_horizontal_small_round_back.cpp
  group Application/User/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group Application/User/TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: MqttMessages.cpp
  group Application/User/TouchGFX/gui/lightscreen_screen
    ../TouchGFX/gui/src/lightscreen_screen/: LightScreenPresenter.cpp LightScreenView.cpp
  group Application/User/TouchGFX/gui/mainscreen_screen
    ../TouchGFX/gui/src/mainscreen_screen/: MainScreenPresenter.cpp MainScreenView.cpp
  group Application/User/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Application/User/TouchGFX/gui/rgbscreen_screen
    ../TouchGFX/gui/src/rgbscreen_screen/: RGBScreenPresenter.cpp RGBScreenView.cpp
  group Application/User/TouchGFX/gui/tempscreen_screen
    ../TouchGFX/gui/src/tempscreen_screen/: TempScreenPresenter.cpp TempScreenView.cpp
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_eeprom.c stm32f429i_discovery_gyroscope.c stm32f429i_discovery_io.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ts.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/ili9341/: ili9341.c
    ../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/MemMgr
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/FreeRTOS/Portable
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/TouchGFX/Lib
    ../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m4f/IAR8.x/: touchgfx_core_release.a
    ../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m4f/IAR/: touchgfx_core_release.a
  group Middlewares/TouchGFX/OS
    ../../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp
  group Middlewares/TouchGFX/Target
    ../TouchGFX/target/: BoardConfiguration.cpp CortexMMCUInstrumentation.cpp GPIO.cpp ResistiveTouchController.cpp STM32F4DMA.cpp STM32F4HAL.cpp
